# Keil uVision project Blinker3.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89F52 Microchip
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(24000000)
  output: Blinker3
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
