# Keil uVision project nor gate1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: nor gate1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: nor gate1.asm nor gate2.asm
